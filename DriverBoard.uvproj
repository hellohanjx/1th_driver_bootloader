# Keil uVision project DriverBoard.uvproj, settings and files
target DriverBoard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: driverbootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output --bin --output ./bin/driverbootloader.bin ./Obj/driverbootloader.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CM3;.\FWlib\inc;.\startup;.\user;.\driver;.\bsp;.\nvic;.\Obj
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ./startup/: startup_stm32f10x_md.s
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group NVIC
    ./nvic/: stm32f10x_it.c
  group DRIVER
    ./driver/: led.c rtc.c systick.c rcc.c uart1.c timer2.c address.c gpio_init.c
  group BSP
    ./bsp/: bsp_led.c bsp_others.c bsp_master.c bsp_timer.c
  group USER
    ./user/: main.c delay.c master_protocol.c
    ./: readme.txt
